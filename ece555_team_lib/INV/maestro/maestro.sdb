<?xml version="1.0"?>
<setupdb version="7">maestro
	<active>Active Setup</active>
	<history>History</history>
</setupdb>
